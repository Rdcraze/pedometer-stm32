# Keil uVision project pedometer_new.uvprojx, settings and files
target pedometer (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myproject +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F40XX
  c include: .\CMSIS;.\Driver;.\Program;.\StdPeriph\inc;.\StdPeriph\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group Driver
    ./Driver/: key.c key.h led.c led.h mpu6050.c mpu6050.h NVIC.c NVIC.h oled.c oled.h timer.c timer.h uart.c uart.h training_load.c training_load.h calories.c calories.h speed_calc.c speed_calc.h pedometer.c pedometer.h buzzer.c buzzer.h flash_data.c flash_data.h key_handler.c key_handler.h
  group Program
    ./Program/: main.c stm32f4xx_it.c stm32f4xx_it.h
  group StdPeriph
    ./StdPeriph/inc/: misc.h stm32f4xx_exti.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_rcc.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h
    ./StdPeriph/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_pwr.c
  group Fonts
    ./Fonts/: font6x8.c font6x8.h font8x16.c font8x16.h font16x16.c font16x16.h
